# Repository oosan1/OU_PowerUnit

## KiCad design Circuit/PowerUnit_Control/PowerUnit_Control.kicad_pcb

Parts:
C1: 1u; C_0603_1608Metric; MPN C15849
C2, C6: 1000u; CP_Radial_D16.0mm_P7.50mm; MPN ルビコンZLH
C3, C7: 10u; C_1206_3216Metric; MPN CL31A106KBHNNNE
C4, C8: 0.1u; C_0603_1608Metric; MPN CC0603KRX7R9BB104
C5, C9: 4.7u; C_0805_2012Metric; MPN CL21A475KAQNNNE
D1, D4, D6: LED; LED_D5.0mm
D2, D3, D5: SS56C; DIODE_SS56C-HF_CIP; MPN C18199187
F1: 5A; FUC-03A
J1: Conn_01x02_Pin; AMASS_XT30PW-M; MPN XT30PW-M
J2, J7, J8, J9, J10, J11: Conn_01x02_Pin; Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical
J3: Conn_01x07_Socket; YDS512F-Unit
J4, J5, J6: Conn_01x02_Pin; AMASS_XT30U-F; MPN XT30PW-M
R1: 7.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 12k; R_0603_1608Metric
R3: 1.5k; R_0603_1608Metric
R4: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RV1: 20k; TRIM_3296W-1-250
U1: M78AR05-1
U2: M78AR033-1

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D1.1 (K), D4.1 (K), D6.1 (K), J1.1, J2.1, J3.3, J3.4, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, R3.2, U1.2 (GND), U2.2 (GND)
unnamed: D1.2 (A), R1.2
unnamed: C1.1, D2.2 (A), D3.2 (A), D5.2 (A), F1.2, R1.1
unnamed: D2.1 (K), J3.1, J3.2
unnamed: C2.1, C3.1, C4.1, D3.1 (K), U1.1 (VI)
unnamed: D4.2 (A), R4.2
unnamed: C6.1, C7.1, C8.1, D5.1 (K), U2.1 (VI)
unnamed: D6.2 (A), R5.2
unnamed: F1.1, J1.2
unnamed: J2.2, J3.5, J3.6, J4.2, J5.2, J6.2, R2.1
unnamed: J3.7, RV1.2
unnamed: C5.1, J7.2, J8.2, J9.2, R4.1, U1.3 (VO)
unnamed: C9.1, J10.2, J11.2, R5.1, U2.3 (VO)
unnamed: R2.2, RV1.3
unnamed: R3.1, RV1.1

Notes on the sheet:
3.3V電源LED
5V電源3
5V電源LED
リニアレギュレータっぽいですが、 ピン互換があるスイッチング レギュレータです
汎用電源3
汎用電源1
5V電源1
電圧モニタ用
低ESRアルミ電解
汎用電源2
制御電源LED
3.3V電源1
3.3V電源2
5V電源2

Board: 2 copper layers, 100.0 x 47.0 mm, 35 parts (12 on the bottom side), 15 nets.

File Circuit/PowerUnit_Control/jlcpcb/production_files/BOM-PowerUnit_Control.csv:

Comment,Designator,Footprint,LCSC,Quantity
0.1u,"C4,C8",C_0603_1608Metric,C14663,2
1.5k,R3,R_0603_1608Metric,C22843,1
10u,"C3,C7",C_1206_3216Metric,C13585,2
12k,R2,R_0603_1608Metric,C22790,1
1u,C1,C_0603_1608Metric,C15849,1
4.7u,"C5,C9",C_0805_2012Metric,C1779,2
SS56C,"D2,D3,D5",DIODE_SS56C-HF_CIP,C18199187,3
5A,F1,FUC-03A,,1
430,R5,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
1000u,C2,CP_Radial_D16.0mm_P7.50mm,,1
Conn_01x02_Pin,J2,Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical,,1
Conn_01x02_Pin,J7,Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical,,1
Conn_01x07_Socket,J3,YDS512F-Unit,,1
Conn_01x02_Pin,J1,AMASS_XT30PW-M,,1
Conn_01x02_Pin,J4,AMASS_XT30U-F,,1
Conn_01x02_Pin,J5,AMASS_XT30U-F,,1
Conn_01x02_Pin,J10,Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical,,1
Conn_01x02_Pin,J8,Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical,,1
7.5k,R1,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
Conn_01x02_Pin,J11,Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical,,1
1000u,C6,CP_Radial_D16.0mm_P7.50mm,,1
Conn_01x02_Pin,J9,Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical,,1
LED,D1,LED_D5.0mm,,1
M78AR05-1,U1,M78AR05-1,,1
1k,R4,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
M78AR033-1,U2,M78AR033-1,,1
20k,RV1,TRIM_3296W-1-250,,1
LED,D4,LED_D5.0mm,,1
Conn_01x02_Pin,J6,AMASS_XT30U-F,,1
LED,D6,LED_D5.0mm,,1

## KiCad design Circuit/PowerUnit_24V/PowerUnit_24V.kicad_pcb

Parts:
C1, C2, C5, C7, C10, C17: 0.1u; C_0603_1608Metric; MPN CC0603KRX7R9BB104
C11, C12: 10u; CP_Radial_D5.0mm_P2.00mm; MPN ルビコンPX
C18: 0.47u; C_0805_2012Metric; MPN CL21B474KBFNNNE
D3, D5, D6: LED; LED_D5.0mm
D4: 1N4148; D_DO-35_SOD27_P2.54mm_Vertical_CathodeUp
F1: 30A; 3557-15_KEY; MPN 3557-15, 0891030.NXS
J1: Conn_01x02_Pin; AMASS_XT60PW-M
J2, J3, J4, J5: Conn_01x02_Pin; AMASS_XT60-F
J6, J7, J8, J9: Conn_01x02_Pin; AMASS_XT30U-F
J10: Conn_01x04_Pin; Hirose_DF1E-04P-2.5DSA
J12: Conn_01x02_Pin; Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical
J13, J19: Conn_01x02_Pin; Hirose_DF1E-2P-2.5DS_1x02_P2.5mm_Horizontal
K1, K2, K3: A31CCQ24VDC1D; DZ85AB5PCB_ForA31CCQ24VDC1D; MPN A31CCQ24VDC1D, DZ85AB-5-PCB
Q1: 2SK4017; TO-251-3_Vertical
R2: 0; R_1206_3216Metric; MPN C17888
R3: 100; R_0603_1608Metric
R4, R6: 10; R_0603_1608Metric
R5: 1m; HoYLR2512E; MPN C5375452
R7, R9, R10: 7.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R8, R17: 100; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R11: 120; R_0603_1608Metric
R12: 10; R_Axial_Power_L25.0mm_W9.0mm_P7.62mm_Vertical
R13: 22k; R_0603_1608Metric
R14: 10k; R_0805_2012Metric
RV2: 500k; TRIM_3362P-1-103
U1: INA226; TSSOP-10_3x3mm_P0.5mm
U2: NJM555D; DIP-8_W7.62mm
U3: NJM7812FA

Connections:
+3.3V: C2.2, C12.1, J10.3, U1.6 (VS)
+12V: C7.2, C11.1, C17.1, U2.4 (~RST), U2.8 (VCC), U3.3 (VO)
+24V_CTRL: C18.1, J6.2, J7.2, J8.2, J9.2, J19.1, K2.30, K3.87, R10.1, R12.2, U3.1 (VI)
+24V_DRV: J2.2, J3.2, J4.2, J5.2, K3.30, R9.1
/I2C_SCL: J10.2, U1.5 (SCL)
/I2C_SDA: J10.4, U1.4 (SDA)
/Vsense1: J12.2, J13.1, K1.87, R3.1, R5.1
GND: C1.2, C2.1, C7.1, C10.1, C12.2, C17.2, C18.2, D4.2 (A), J6.1, J7.1, J8.1, J9.1, J10.1, R2.2, RV2.2, U1.1 (A1), U1.2 (A0), U1.7 (GND), U2.1 (GND), U3.2 (GND)
GNDPWR: D3.1 (K), D5.1 (K), D6.1 (K), J1.1, J2.1, J3.1, J4.1, J5.1, J12.1, K1.85, K3.85, Q1.3 (S), R2.1, R8.1, R14.2, R17.1
unnamed: D3.2 (A), R7.2
unnamed: C11.2, D4.1 (K), R13.1, U2.2 (TRIG), U2.6 (THRES)
unnamed: D5.2 (A), R9.2
unnamed: D6.2 (A), R10.2
unnamed: F1.2, R5.4, R7.1
unnamed: F1.1, J1.2
unnamed: J13.2, K1.86
unnamed: J19.2, K3.86
unnamed: K1.30, K2.86, K2.87, R12.1
unnamed: K1.87a, R8.2
unnamed: K3.87a, R17.2
unnamed: K2.85, Q1.2 (D)
unnamed: Q1.1 (G), R11.2, R14.1
unnamed: R4.2, R5.3
unnamed: R5.2, R6.1
unnamed: R13.2, RV2.1
unnamed: C1.1, R3.2, U1.8 (Vbus)
unnamed: C5.1, R4.1, U1.10 (Vin+)
unnamed: C5.2, R6.2, U1.9 (Vin-)
unnamed: C10.2, U2.5 (CONT)
unnamed: R11.1, U2.3 (OUT)

Notes on the sheet:
電圧モニタ用
駆動用電源
制御用電源
メインスイッチ
メイン電源スイッチ &コンデンサ放電用
12V
可変抵抗による調整範囲 0.24秒 ~ 5.7秒
遅延回路
バッテリーLED
突入電流対策用
非常停止ボタン
駆動電源LED
24Vフロントエンド
Ad: 0
1点アース

Board: 2 copper layers, 100.0 x 76.0 mm, 49 parts (16 on the bottom side), 30 nets.

File Circuit/PowerUnit_24V/jlcpcb/production_files/BOM-PowerUnit_24V.csv:

Comment,Designator,Footprint,LCSC,Quantity
0,R2,R_1206_3216Metric,C17888,1
0.1u,"C1,C10,C17,C2,C5,C7",C_0603_1608Metric,C14663,6
0.47u,C18,C_0805_2012Metric,C13967,1
10,"R4,R6",R_0603_1608Metric,C22859,2
100,R3,R_0603_1608Metric,C22775,1
10k,R14,R_0805_2012Metric,C17414,1
120,R11,R_0603_1608Metric,C22787,1
1m,R5,HoYLR2512E,C5375452,1
22k,R13,R_0603_1608Metric,C31850,1
INA226,U1,TSSOP-10_3x3mm_P0.5mm,C49851,1
電圧メータ_秋月_超小型,REF**,電圧メータ_秋月_超小型,,1
2SK4017,Q1,TO-251-3_Vertical,,1
10,R12,R_Axial_Power_L25.0mm_W9.0mm_P7.62mm_Vertical,,1
Conn_01x02_Pin,J7,AMASS_XT30U-F,,1
10u,C11,CP_Radial_D5.0mm_P2.00mm,,1
A31CCQ24VDC1D,K1,DZ85AB5PCB_ForA31CCQ24VDC1D,,1
Conn_01x02_Pin,J8,AMASS_XT30U-F,,1
10u,C12,CP_Radial_D5.0mm_P2.00mm,,1
1N4148,D4,D_DO-35_SOD27_P2.54mm_Vertical_CathodeUp,,1
7.5k,R7,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
Conn_01x02_Pin,J13,Hirose_DF1E-2P-2.5DS_1x02_P2.5mm_Horizontal,,1
LED,D6,LED_D5.0mm,,1
Conn_01x02_Pin,J2,AMASS_XT60-F,,1
Conn_01x02_Pin,J1,AMASS_XT60PW-M,,1
NE555P,U2,DIP-8_W7.62mm,,1
Conn_01x02_Pin,J5,AMASS_XT60-F,,1
7.5k,R10,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
A31CCQ24VDC1D,K3,DZ85AB5PCB_ForA31CCQ24VDC1D,,1
A31CCQ24VDC1D,K2,DZ85AB5PCB_ForA31CCQ24VDC1D,,1
LED,D3,LED_D5.0mm,,1
LED,D5,LED_D5.0mm,,1
500k,RV2,TRIM_3362P-1-103,,1
Conn_01x02_Pin,J3,AMASS_XT60-F,,1
Conn_01x04_Pin,J10,Hirose_DF1E-04P-2.5DSA,,1
Conn_01x02_Pin,J12,Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical,,1
7.5k,R9,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
Conn_01x02_Pin,J4,AMASS_XT60-F,,1
100,R17,R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical,,1
Conn_01x02_Pin,J19,Hirose_DF1E-2P-2.5DS_1x02_P2.5mm_Horizontal,,1
Conn_01x02_Pin,J6,AMASS_XT30U-F,,1
Conn_01x02_Pin,J9,AMASS_XT30U-F,,1
30A,F1,3557-15_KEY,,1
NJM7812FA,U3,NJM7812FA,,1
100,R8,R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical,,1

## KiCad design Circuit/PowerUnit_Motor/PowerUnit_Motor.kicad_pcb

Parts:
C3, C4: 1000u; CP_Radial_D16.0mm_P7.50mm; MPN ルビコンZLH
D1: LED; LED_D5.0mm
D2: SMCJ26A; SMCJSeries_LTF
J1: Conn_01x02_Pin; AMASS_XT60PW-M
J2, J3, J4, J5, J6, J7, J8, J9: Conn_01x02_Pin; AMASS_XT60PW-F; MPN XT30PW-M
J10, J11: Conn_01x02_Pin; AMASS_XT60-F; MPN XT30PW-M
R1: 7.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical

Connections:
+24V_DRV: C3.1, C4.1, D2.1 (K), J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, R1.1
GNDPWR: C3.2, C4.2, D1.1 (K), D2.2 (A), J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1
unnamed: D1.2 (A), R1.2

Notes on the sheet:
低ESRアルミ電解
電源LED

Board: 2 copper layers, 100.0 x 57.0 mm, 16 parts (1 on the bottom side), 3 nets.

File Circuit/PowerUnit_Motor/jlcpcb/production_files/BOM-PowerUnit_Motor.csv:

Comment,Designator,Footprint,LCSC,Quantity
Conn_01x02_Pin,J1,AMASS_XT60PW-M,,1
Conn_01x02_Pin,J9,AMASS_XT60PW-F,,1
Conn_01x02_Pin,J6,AMASS_XT60PW-F,,1
Conn_01x02_Pin,J3,AMASS_XT60PW-F,,1
Conn_01x02_Pin,J5,AMASS_XT60PW-F,,1
Conn_01x02_Pin,J11,AMASS_XT60-F,,1
Conn_01x02_Pin,J10,AMASS_XT60-F,,1
1000u,C4,CP_Radial_D16.0mm_P7.50mm,,1
7.5k,R1,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
Conn_01x02_Pin,J4,AMASS_XT60PW-F,,1
Conn_01x02_Pin,J2,AMASS_XT60PW-F,,1
Conn_01x02_Pin,J7,AMASS_XT60PW-F,,1
Conn_01x02_Pin,J8,AMASS_XT60PW-F,,1
LED,D1,LED_D5.0mm,,1
1000u,C3,CP_Radial_D16.0mm_P7.50mm,,1
SMLJ24A-Q,D2,SMCJSeries_LTF,,1

## KiCad design Circuit/PowerUnit_Servo/PowerUnit_Servo.kicad_pcb

Parts:
D1: LED; LED_D5.0mm
J1: Conn_01x02_Pin; AMASS_XT60PW-M
J2: Conn_01x02_Pin; Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical
J3, J6, J9: Conn_01x07_Socket; YDS512F-Unit
J4, J5, J7, J8, J10, J11: Conn_01x02_Pin; AMASS_XT30U-F; MPN XT30PW-M
R1: 7.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R4, R6: 12k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3, R5, R7: 1.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RV1, RV2, RV3: 20k; TRIM_3296W-1-250
SW1: SW_Toggle_DPDT; 1MD6-T1-B1-M1-Q-N-S

Connections:
GNDPWR: D1.1 (K), J1.1, J2.1, J3.3, J3.4, J4.1, J5.1, J6.3, J6.4, J7.1, J8.1, J9.3, J9.4, J10.1, J11.1, R3.2, R5.2, R7.2; also elsewhere on the board
unnamed: D1.2 (A), R1.2
unnamed 2: J1.2, J3.1, J3.2, J6.1, J6.2, J9.1, J9.2, R1.1; also elsewhere on the board
unnamed: J2.2, SW1.2 (B)
unnamed: J3.5, J3.6, J4.2, J5.2, R2.1, SW1.1 (A)
unnamed: J3.7, RV1.2
unnamed: J6.5, J6.6, J7.2, J8.2, R4.1, SW1.4 (A)
unnamed: J6.7, RV2.2
unnamed: J9.7, RV3.2
unnamed: J9.5, J9.6, J10.2, J11.2, R6.1, SW1.6 (C)
unnamed: R2.2, RV1.3
unnamed: R3.1, RV1.1
unnamed: R4.2, RV2.3
unnamed: R5.1, RV2.1
unnamed: R6.2, RV3.3
unnamed: R7.1, RV3.1
unnamed: SW1.3 (C), SW1.5 (B)

Notes on the sheet:
サーボ汎用1.1
サーボ汎用2.1
電圧モニタ用
サーボ汎用3.2
サーボ汎用2.2
サーボ汎用1.2
駆動電源LED
サーボ汎用3.1

Board: 2 copper layers, 100.0 x 60.0 mm, 25 parts (0 on the bottom side), 17 nets.

Other parts of the board:
C1: 1u; C_Disc_D6.0mm_W4.4mm_P5.00mm
C2: 470u; CP_Radial_D10.0mm_P5.00mm

Their connections:
GNDPWR: C1.2, C2.2; also elsewhere on the board
unnamed 2: C1.1, C2.1; also elsewhere on the board

File Circuit/PowerUnit_Servo/jlcpcb/production_files/BOM-PowerUnit_Servo.csv:

Comment,Designator,Footprint,LCSC,Quantity
Conn_01x02_Pin,J10,AMASS_XT30U-F,,1
Conn_01x02_Pin,J7,AMASS_XT30U-F,,1
12k,R6,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
Conn_01x02_Pin,J5,AMASS_XT30U-F,,1
1u,C1,C_Disc_D6.0mm_W4.4mm_P5.00mm,,1
Conn_01x02_Pin,J4,AMASS_XT30U-F,,1
7.5k,R1,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
電圧メータ_秋月_超小型,REF**,電圧メータ_秋月_超小型,,1
12k,R4,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
SW_Toggle_DPDT,SW1,1MD6-T1-B1-M1-Q-N-S,,1
Conn_01x07_Socket,J9,YDS512F-Unit,,1
Conn_01x07_Socket,J3,YDS512F-Unit,,1
LED,D1,LED_D5.0mm,,1
12k,R2,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
Conn_01x02_Pin,J2,Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical,,1
1.5k,R7,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
1.5k,R5,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
20k,RV3,TRIM_3296W-1-250,,1
1.5k,R3,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,,1
Conn_01x02_Pin,J11,AMASS_XT30U-F,,1
Conn_01x02_Pin,J1,AMASS_XT60PW-M,,1
Conn_01x02_Pin,J8,AMASS_XT30U-F,,1
20k,RV1,TRIM_3296W-1-250,,1
Conn_01x07_Socket,J6,YDS512F-Unit,,1
470u,C2,CP_Radial_D10.0mm_P5.00mm,,1
20k,RV2,TRIM_3296W-1-250,,1

## KiCad design Circuit/YDS512F_Unit/YDS512F_Unit.kicad_pcb

Parts:
C1: 220u; CP_Radial_D10.0mm_P5.00mm; MPN ルビコンZLH
C2: 47u; CP_Radial_D8.0mm_P3.50mm; MPN 47μF63V125℃ PZJ
C3: 2.2u; C_Disc_D6.0mm_W4.4mm_P5.00mm
C4: 100u; CP_Radial_D10.0mm_P5.00mm; MPN 100μF50V125℃ PZF
C5: 470u; CP_Radial_D10.0mm_P5.00mm; MPN ルビコンZLH
J1: Conn_01x07_Pin; PinHeader_1x07_P2.54mm_Horizontal
U1: YDS512F

Connections:
unnamed: J1.1, U1.7 (Vadj)
unnamed: C4.1, C5.1, J1.2, J1.3, U1.5 (VOUT), U1.6 (VOUT)
unnamed: C1.2, C2.2, C3.2, C4.2, C5.2, J1.4, J1.5, U1.3 (GND), U1.4 (GND)
unnamed: C1.1, C2.1, C3.1, J1.6, J1.7, U1.1 (Vin), U1.2 (Vin)

Notes on the sheet:
導電性高分子
低ESRアルミ電解

Board: 2 copper layers, 43.5 x 51.5 mm, 7 parts (0 on the bottom side), 4 nets.
