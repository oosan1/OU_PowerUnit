# Repository oosan1/OU_PowerUnit (continued)

## KiCad design Circuit/PowerUnit/PowerUnit.kicad_pcb

Parts:
C1, C2, C5, C7, C10, C19, C41, C47: 0.1u; C_0603_1608Metric; MPN CC0603KRX7R9BB104
C3, C4, C30, C38, C39, C45: 1000u; CP_Radial_D16.0mm_P7.50mm; MPN ルビコンZLH
C6, C16, C25: 220u; CP_Radial_D10.0mm_P5.00mm; MPN ルビコンZLH
C8, C17, C26, C32: 47u; CP_Radial_D8.0mm_P3.50mm; MPN 47μF63V125℃ PZJ
C9, C18, C27: 2.2u; C_Disc_D6.0mm_W4.4mm_P5.00mm
C13: 10u; CP_Radial_D5.0mm_P2.00mm; MPN ルビコンPX
C14, C23, C31, C37: 100u; CP_Radial_D10.0mm_P5.00mm; MPN 100μF50V125℃ PZF
C15, C24, C33: 470u; CP_Radial_D10.0mm_P5.00mm; MPN ルビコンZLH
C21: 0.47u; C_0805_2012Metric; MPN CL21B474KBFNNNE
C34: 2.2u; C_0805_2012Metric; MPN CL21A225KBQNNNE
C40, C46: 10u; C_1206_3216Metric; MPN CL31A106KBHNNNE
C43, C49: 4.7u; C_0805_2012Metric; MPN CL21A475KAQNNNE
D1, D3, D5, D8, D10: LED; LED_D5.0mm
D2: SMCJ24A; SMCJSeries_LTF; MPN C19077604
D4: 1N4148; D_DO-35_SOD27_P2.54mm_Vertical_CathodeUp
D6, D7, D9: SS56C; DIODE_SS56C-HF_CIP; MPN C18199187
F1: 30A; 3557-15_KEY; MPN 3557-15, 0891030.NXS
J1: Conn_01x02_Pin; AMASS_XT60PW-M
J2, J3, J4, J5, J6, J34, J35, J36: Conn_01x02_Pin; AMASS_XT30PW-M; MPN XT30PW-M
J7, J8, J9, J10, J11, J15, J21, J27: Conn_01x02_Pin; XT30U-M; MPN XT30PW-M
J12, J14, J33, J39, J40, J41, J42, J43, J44: Conn_01x02_Pin; Hirose_DF1EC-2P-2.5DSA_1x02_P2.5mm_Vertical
J13, J24: Conn_01x02_Pin; Hirose_DF1E-2P-2.5DS_1x02_P2.5mm_Horizontal
J16, J22, J28, J32: Conn_01x07_Socket; YDS512F-Unit
J17, J18, J19, J23, J25, J26, J29, J30, J31, J38: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J37: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical
K1, K2, K3: A31CCQ24VDC1D; DZ85AB5PCB_ForA31CCQ24VDC1D; MPN A31CCQ24VDC1D, DZ85AB-5-PCB
Q1: 2SK4017; TO-251-3_Vertical
R1, R7, R24: 7.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 0; R_1206_3216Metric; MPN C17888
R3: 100; R_0603_1608Metric
R4, R6: 10; R_0603_1608Metric
R5: 1m; HoYLR2512E; MPN C5375452
R8, R22: 100; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R9, R18, R25, R30: 12k; R_0603_1608Metric
R10, R19, R26, R31: 1.5k; R_0603_1608Metric
R11: 120; R_0603_1608Metric
R12: 10; R_Axial_Power_L25.0mm_W9.0mm_P7.62mm_Vertical
R13: 22k; R_0603_1608Metric
R16: 10k; R_0805_2012Metric
R32, R33: 2.2k; R_0603_1608Metric
R40: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R44: 430; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RV1, RV3, RV4, RV5: 20k; TRIM_3296W-1-250
RV2: 500k; TRIM_3362P-1-103
SW1: SW_Toggle_DPDT; 1MD6-T1-B1-M1-Q-N-S
U1: INA226; TSSOP-10_3x3mm_P0.5mm
U3: NE555P; DIP-8_W7.62mm
U4: NJM7812FA
U9: M78AR05-1
U11: M78AR033-1

Connections:
+3.3V: C49.1, J38.3, J42.2, J43.2, J44.2, R32.2, R33.2, R44.1, U11.3 (VO)
+5V: C2.2, C43.1, J38.2, J39.2, J40.2, J41.2, R40.1, U1.6 (VS), U9.3 (VO)
+12V: C7.2, C13.1, C19.1, U3.4 (~RST), U3.8 (VCC), U4.3 (VO)
+24V_CTRL: C21.1, D6.2 (A), D7.2 (A), D9.2 (A), J24.1, K2.30, K3.87, R3.1, R12.2, R24.1, U4.1 (VI)
+24V_DRV: C3.1, C4.1, C6.1, C8.1, C9.1, C16.1, C17.1, C18.1, C25.1, C26.1, C27.1, D2.1 (K), J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J16.1, J16.2, J22.1, J22.2, J28.1, J28.2, K3.30, R1.1
/I2C_SCL: R32.1, U1.5 (SCL)
/I2C_SDA: R33.1, U1.4 (SDA)
/サーボ_通信1: J17.1, J37.2
/サーボ_通信2: J18.1, J37.3
/サーボ_通信3: J19.1, J37.4
/サーボ_通信4: J23.1, J37.5
/サーボ_通信5: J25.1, J37.6
/サーボ_通信6: J26.1, J37.7
/サーボ_通信7: J29.1, J37.8
/サーボ_通信8: J30.1, J37.9
/サーボ_通信9: J31.1, J37.10
GND: C1.1, C2.1, C7.1, C10.1, C19.2, C21.2, C30.2, C32.2, C34.2, C37.2, C38.2, C39.2, C40.2, C41.2, C43.2, C45.2, C46.2, C47.2, C49.2, D1.1 (K), D3.1 (K), D4.2 (A), D5.1 (K), D8.1 (K), D10.1 (K), J12.1, J14.1, J32.3, J32.4, J33.1, J34.1, J35.1, J36.1, J37.1, J38.1, J39.1, J40.1, J41.1, J42.1, J43.1, J44.1, R2.2, R31.2, RV2.2, U1.1 (A1), U1.2 (A0), U1.7 (GND), U3.1 (GND), U4.2 (GND), U9.2 (GND), U11.2 (GND)
GNDPWR: C3.2, C4.2, C6.2, C8.2, C9.2, C14.2, C15.2, C16.2, C17.2, C18.2, C23.2, C24.2, C25.2, C26.2, C27.2, C31.2, C33.2, D2.2 (A), J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J15.1, J16.3, J16.4, J17.3, J18.3, J19.3, J21.1, J22.3, J22.4, J23.3, J25.3, J26.3, J27.1, J28.3, J28.4, J29.3, J30.3, J31.3, K1.85, K3.85, Q1.3 (S), R2.1, R8.1, R10.2, R16.2, R19.2, R22.1, R26.2
unnamed: D1.2 (A), R1.2
unnamed: D3.2 (A), R7.2
unnamed: C13.2, D4.1 (K), R13.1, U3.2 (TRIG), U3.6 (THRES)
unnamed: D5.2 (A), R24.2
unnamed: C30.1, C32.1, C34.1, D6.1 (K), J32.1, J32.2
unnamed: C39.1, C40.1, C41.1, D7.1 (K), U9.1 (VI)
unnamed: D8.2 (A), R40.2
unnamed: C45.1, C46.1, C47.1, D9.1 (K), U11.1 (VI)
unnamed: D10.2 (A), R44.2
unnamed: F1.2, R5.4
unnamed: F1.1, J1.2
unnamed: J12.2, J13.1, K1.87, R5.1, R7.1
unnamed: J13.2, K1.86
unnamed: J14.2, SW1.2 (B)
unnamed: C14.1, C15.1, J15.2, J16.5, J16.6, J17.2, J18.2, J19.2, R9.1, SW1.1 (A)
unnamed: J16.7, RV1.2
unnamed: C23.1, C24.1, J21.2, J22.5, J22.6, J23.2, J25.2, J26.2, R18.1, SW1.4 (A)
unnamed: J22.7, RV3.2
unnamed: J24.2, K3.86
unnamed: C31.1, C33.1, J27.2, J28.5, J28.6, J29.2, J30.2, J31.2, R25.1, SW1.6 (C)
unnamed: J28.7, RV4.2
unnamed: C37.1, C38.1, J32.5, J32.6, J33.2, J34.2, J35.2, J36.2, R30.1
unnamed: J32.7, RV5.2
unnamed: K1.30, K2.86, K2.87, R12.1
unnamed: K1.87a, R8.2
unnamed: K3.87a, R22.2
unnamed: K2.85, Q1.2 (D)
unnamed: Q1.1 (G), R11.2, R16.1
unnamed: R4.2, R5.3
unnamed: R5.2, R6.1
unnamed: R9.2, RV1.3
unnamed: R10.1, RV1.1
unnamed: R13.2, RV2.1
unnamed: R18.2, RV3.3
unnamed: R19.1, RV3.1
unnamed: R25.2, RV4.3
unnamed: R26.1, RV4.1
unnamed: R30.2, RV5.3
unnamed: R31.1, RV5.1
unnamed: SW1.3 (C), SW1.5 (B)
unnamed: C1.2, R3.2, U1.8 (Vbus)
unnamed: C5.1, R4.1, U1.10 (Vin+)
unnamed: C5.2, R6.2, U1.9 (Vin-)
unnamed: C10.2, U3.5 (CONT)
unnamed: R11.1, U3.3 (OUT)

Notes on the sheet:
サーボ3
導電性高分子
制御電源LED
低ESRアルミ電解
3.3V電源1
汎用電源1
駆動電源LED
5V電源LED
サーボ
3.3V電源2
メインスイッチ
5V電源2
汎用電源2
サーボ6
Ad: 0
積層セラミック
バッテリーLED
3.3V電源LED
電圧モニタ用
サーボ汎用1
汎用電源3
12V
サーボ9
5V電源1
24Vフロントエンド
制御系電源
非常停止ボタン
サーボ4
可変抵抗による調整範囲 0.24秒 ~ 5.7秒
遅延回路
サーボ5
サーボ1
5V電源3
1点アース
サーボ汎用2
サーボ8
メイン電源スイッチ &コンデンサ放電用
駆動系電源
ロボマス
サーボ汎用3

Board: 2 copper layers, 133 parts (30 on the bottom side), 63 nets, no tracks yet.

## Commit log

2026-06-14 回路図ver1完成
2026-06-15 コンデンサ、ダイオード、コネクタまでフットプリント割り当て
2026-06-16 一旦、切り替えスイッチまでフットプリント割り当て済み
2026-06-16 フットプリントの割り当て完了
2026-06-16 電流センサにフィルターを追加
2026-06-16 間違えていたフットプリントを一部更新
2026-06-17 途中までPCBを配置
2026-06-17 駆動系はほぼほぼ配置が終わった
2026-06-18 スペースの問題から電流センサを減らした
2026-06-18 全ての配置が終わった
2026-06-19 別基板化 24V基板の配置完了
2026-06-19 24V基板完成
2026-06-19 メインモータ基板完成
2026-06-21 24V基板とメインモータ基板を修正
2026-06-21 YDS512F基板完成 24V基板とメインモータ基板を微修正
2026-06-21 サーボ基板完成
2026-06-22 制御電源基板が完成
2026-06-22 Geminiに確認してもらって一部修正
2026-06-22 再度修正
2026-06-22 発注用データを用意 発注した
